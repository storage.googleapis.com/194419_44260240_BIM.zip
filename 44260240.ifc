Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T18:53:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 18:53:26 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\967f93b0-db20-40dd-824c-a9dd289fac8e\ifc * Database version: 5507 * Database creation date: Fri Apr 26 18:53:26 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 18:53:26 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 18:53:26 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 44260240 Overhead shower, 200x200 mm, 44260240:44260240 Overhead shower, 200x200 mm:21498
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 448.2 mm; NominalHeight: 123.945 mm; NominalWidth: 199.4 mm
Type - General - Author: BIMStone; BIMObjectName: 44260240; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - EAN Number: 4015474257429; ETIM Class Number: EC011383 Shower head; Noise Class: II (ISO 3822); Sales Package dimensions (LxWxH): 428 x 318 x 67; UNSPSC Class Number: 30181801 Shower head; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/44260240; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/44260240; 3D View: https://static.hansa.com/AR/44260240; Catalog Drawing URL: http://static.hansa.com/catdrw/44260240; Dimension Drawing URL: http://static.hansa.com/dimdrw/44260240; FDV Document URL: http://www.hansa.com/datasheet/44260240/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/44260240; Group: Overhead shower; Installation and Maintenance Guide URL: http://static.hansa.com/manual/44260240; Interactive AR View URL: https://static.hansa.com/AR/44260240; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/44260240; Model: 44260240 Overhead shower, 200x200 mm; Name_en: 44260240 Overhead shower, 200x200 mm; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 44260240; Product Family: HANSAVIVA; Product Image URL: http://static.hansa.com/image/44260240; Product URL: http://static.hansa.com/44260240; Spare-Part Information URL: http://static.hansa.com/sp/44260240; Technical DataSheet URL: http://www.hansa.com/datasheet/44260240/en; Type Name: 44260240 Overhead shower, 200x200 mm; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Connection Size: G1/2; Flow Rate At 300kPa With Flow Controller: 0.00706293 m3/s; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Over Head Shower Size: 200 x 200 mm; Shower Parts: Overhead shower;Eco flow control;Rotatable ball joint connection;Anti limescale technology (easy to clean); Shower Spray: Rain; Shower Spray Number: 1 shower spray; Spout Projection: 357 mm; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 44260240; Features: n/a; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 44260240; Name: 44260240 Overhead shower, 200x200 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 200x450x125 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.169638 m2; Volume: 0.0110771 m3
Identity Data - Mark: 9
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 44260240: 44260240 Overhead shower, 200x200 mm; Family and Type: 44260240: 44260240 Overhead shower, 200x200 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 44260240: 44260240 Overhead shower, 200x200 mm; Type Id: 44260240: 44260240 Overhead shower, 200x200 mm; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
